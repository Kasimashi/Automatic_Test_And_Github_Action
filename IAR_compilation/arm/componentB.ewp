# IAR project componentB.ewp, settings and files
configuration Debug (ARM, debug)
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ../portable/library
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: $EXE_DIR$/library.a
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../portable/componentB/: componentB.c
