# IAR project componentB.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: RV32 RV32
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCIncludePath2: ../portable/library
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: $EXE_DIR$/library.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: componentB.out
  group (top)
    ../portable/componentB/: componentB.c
