# IAR project componentB.ewp, settings and files
configuration Debug (RH850, debug)
  General.GDeviceSelect: UnspecifiedG3M RH850 G3M - Unspecified
  General.GHeapSize: 0x1000
  ICCRH850.IccLang: 0
  ICCRH850.CCOptLevel: 1
  ICCRH850.CCOptStrategy: 0
  ICCRH850.CCIncludePath2: ../portable/library
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkrh850_g3m.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: $EXE_DIR$/library.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RH850)
  as the first configuration, except:
  ICCRH850.CCOptLevel: 3
  ICCRH850.CCDefines: NDEBUG
  group (top)
    ../portable/componentB/: componentB.c
