# IAR project library.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: ../portable/library
  ILINK.IlinkOutputFile: library.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group (top)
    ../portable/library/: crc32.c debug_log.c divisionByZero.c math_log.c math_mul.c math_sum.c nullAssign.c unreachableCode.c
